# Keil uVision project ant_network_processor_s3xx.uvprojx, settings and files
target nrf52 (5060020::V5.06 (build 20)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ant_network_processor_s332 +hex
  BeforeMake: .\clean.bat
  c flags: Optim=1
  c define: NRF52
  c misc: --c99
  c include: .\inc;.\inc\S332;..\..\common\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x27000 size 0x59000
  memory RVCT9: RAM 0x20003800 size 0xc800
  group main
    ./src/: main.c version.c
    ../../common/src/: command.c dsi_utility.c global.c serial.c svc_app.c system.c exception_handler.s
target nrf51 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51422_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.7.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ant_network_processor_s310 +hex
  BeforeMake: .\clean.bat
  c flags: Optim=1 wLevel=2
  c define: NRF51
  c include: .\inc;.\inc\S310;..\..\common\inc
  asm misc: --cpreproc
  memory RVCT4: ROM 0x1d000 size 0x23000
  memory RVCT9: RAM 0x20002200 size 0x1e00
software components: CMSIS:CORE 4.1.0, CMSIS:CORE 5.0.0, Device:Startup 8.5.0, Device:Startup 8.7.1
